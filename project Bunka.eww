<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>useful</name>
      <member>
        <project>project</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


